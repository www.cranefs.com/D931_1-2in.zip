# Autodesk Inventor part: D931_1-2in
## iProperties
Created: 2011-03
Part Number: D931_1-2in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
